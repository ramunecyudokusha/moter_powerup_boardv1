# Repository ramunecyudokusha/moter_powerup_boardv1

File README.md:

# moter_powerup_boardv1
汎用モタドラへの増設基板

## KiCad design moter_upgrade_boardv1.kicad_pcb

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C5: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED_YELLOW; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: LED_Green; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x05_Socket; JST_XH_S5B-XH-A-1_1x05_P2.50mm_Horizontal
J2: Conn_ST_STDC14; PinHeader_2x07_P1.27mm_Vertical
J3, J4, J5: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J6: Conn_01x03_Pin; TerminalBlock_RND_205-00233_1x03_P5.08mm_Horizontal
R1: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R6, R7, R8: 10k; R_0805_2012Metric
SW1: SW_Wuerth_450301014042; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW2, SW3, SW4: SW_Push; SW_PUSH_6mm
U1: TCAN3414DRBR; XCVR_TCAN3414DRBR; PARTREV A
U2: STM32C092CBT6; LQFP48_STM

Connections:
+3.3V: C1.2, C2.2, C3.1, C4.1, J1.2, J2.3 (VCC), J5.2, R5.1, R6.1, R7.1, R8.1, U1.3 (VCC), U2.5 (VREF+), U2.6 (VDD/VDDA)
/ma: R7.2, SW2.1, U2.26 (PB14)
/mb: R5.2, SW3.1, U2.25 (PB13)
CAN1R: R1.2, SW1.2 (C)
CAN1_+: J3.1, J4.2, R1.1, U1.7 (CANH)
CAN1_-: J3.2, J4.1, SW1.1 (B), U1.6 (CANL)
CAN1rx: U1.4 (RXD), U2.19 (PB0)
CAN1tx: U1.1 (TXD), U2.20 (PB1)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, J1.5, J2.5 (GND), J2.7 (GND), J2.11 (GNDDetect), J5.1, J6.3, R2.1, R3.1, R4.2, SW2.2, SW3.2, SW4.2, U1.2 (GND), U1.5 (SHDN), U1.8 (STB), U1.9 (EXP), U2.7 (VSS/VSSA)
unnamed: D1.2 (A), U2.24 (PB12)
unnamed: D1.1 (K), R2.2
unnamed: D2.2 (A), U2.23 (PB11)
unnamed: D2.1 (K), R3.2
dir to moter: J6.1, U2.12 (PA1)
en-a: J1.3, U2.46 (PB7)
en-b: J1.1, U2.45 (PB6)
en-x: J1.4
nrst: C5.1, J2.12 (~RST), R6.2, SW4.1, U2.10 (PF2-NRST)
pwm to moter: J6.2, U2.11 (PA0)
strx: J2.13 (VCP_RX), U2.28 (PA8)
sttx: J2.14 (VCP_TX), U2.29 (PA9)
swclk: J2.6 (JCLK/SWCLK), R4.1, U2.36 (PA14-BOOT0)
swdio: J2.4 (JTMS/SWDIO), R8.2, U2.35 (PA13)

Notes on the sheet:
リセット用スイッチ
エンコーダ用

Board: 2 copper layers, 52.0 x 50.0 mm, 31 parts (12 on the bottom side), 22 nets.

File production/MotorUpGradeBoardV2_bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C3, C5",0603,3,0.1uF,
C2,0603,1,4.7uF,
C4,0603,1,1uf,
D1,0805,1,LED_YELLOW,
D2,0805,1,LED_Green,
J1,JST_XH_S5B-XH-A-1_1x05_P2.50mm_Horizontal,1,Conn_01x05_Socket,
J2,PinHeader_2x07_P1.27mm_Vertical,1,Conn_ST_STDC14,
"J3, J4, J5",JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal,3,Conn_01x02_Socket,
J6,TerminalBlock_RND_205-00233_1x03_P5.08mm_Horizontal,1,Conn_01x03_Pin,
R1,0603,1,120,
"R2, R3",0603,2,1k,
"R4, R5, R6, R7, R8",0805,5,10k,
SW1,SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm,1,SW_Wuerth_450301014042,
"SW2, SW3, SW4",SW_PUSH_6mm,3,SW_Push,
U1,XCVR_TCAN3414DRBR,1,TCAN3414DRBR,
U2,LQFP48_STM,1,STM32C092CBT6,

## Commit log

2026-04-15 絶縁回路の作成
2026-04-16 MCUをF446からH523へ置き換え
2026-04-17 回路図の作図
2026-04-17 フットプリントの一部変更と部品配置
2026-04-18 md13s用ブランチ作成
2026-04-18 13sと10cでブランチ
2026-04-19 配線、配置変更など いったん完成
2026-04-19 CAN端子の追加
2026-04-20 usbCをもとに戻した 最終？？版
2026-04-21 回路図の書き換え 部品配置配線のリセット
2026-04-21 電源供給を切り替えられるように変更 部品配置の変更
2026-04-24 stlinkをstdc14に対応させた 部品配置の変更
2026-05-07 マイコンの置き換え
    stmH5からstmC5に置き換え(C5の中身はf446)
2026-05-11 test
2026-05-11 5v降圧レギュレーターの追加
2026-06-14 一応
    バックアップ的な感じ
2026-06-14 ver1の再アップロード&統合
2026-06-17 基本構成の大幅変更(マイコンも変わった
2026-06-22 ver2完成発注(データ同梱)
